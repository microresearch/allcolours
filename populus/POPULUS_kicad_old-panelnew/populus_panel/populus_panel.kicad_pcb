# Repository microresearch/allcolours (continued)

## KiCad design touch/touch_kicad_new2024/touch.kicad_pcb (continued)

Schematic: inp.kicad_sch

Parts:
C17: 100nF; C_0805_2012Metric
C18, C19, C20, C25: 1nF; C_0805_2012Metric
C26: 100N; C_0805_2012Metric
D12: LM4040; SOT-23
R13, R15, R19, R21: 100K; R_0805_2012Metric
R14, R16, R20, R22: 200K; R_0805_2012Metric
R17, R18, R23, R24: 33K; R_0805_2012Metric
R25: 100R; R_0805_2012Metric
U5: MCP6004; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3.3V: C17.1, U5.4 (V+); also elsewhere on the board
-12VA: R25.2
ADC8: C18.1, R17.1, U5.1; also elsewhere on the board
ADC9: C19.1, R18.1, U5.7; also elsewhere on the board
ADC10: C20.1, R23.1, U5.8; also elsewhere on the board
ADC11: C25.1, R24.1, U5.14; also elsewhere on the board
AREF-10: C26.2, D12.2 (A), R14.2, R16.2, R20.2, R22.2, R25.1
C1: R13.2; also elsewhere on the board
C2: R15.2; also elsewhere on the board
C3: R19.2; also elsewhere on the board
C4: R21.2; also elsewhere on the board
GND: C17.2, C26.1, D12.1 (K), U5.3 (+), U5.5 (+), U5.10 (+), U5.11 (V-), U5.12 (+); also elsewhere on the board
unnamed: C18.2, R13.1, R14.1, R17.2, U5.2 (-)
unnamed: C19.2, R15.1, R16.1, R18.2, U5.6 (-)
unnamed: C20.2, R19.1, R20.1, R23.2, U5.9 (-)
unnamed: C25.2, R21.1, R22.1, R24.2, U5.13 (-)

Notes on the sheet:
Input for adc 8-11 from C1-C4
changed form 470R 24/2
-5 to 5v (clouds)

Board: 2 copper layers, 101.3 x 108.5 mm, 157 parts (143 on the bottom side), 130 nets.

## KiCad design touch/touch_kicad_new2024/touch_panel_filter/touch_panel.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: 10nF; C_0805_2012Metric
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42: Conn_01x01; TestPoint_Pad_1.0x1.0mm
J43: Conn_02x20_Counter_Clockwise; PinHeader_2x20_P2.54mm_Vertical_SMD
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11: 47K; R_0805_2012Metric

Connections:
+3V3: J43.4, J43.39
+12V: J43.5, J43.12; also elsewhere on the board
ADC0: J43.21; also elsewhere on the board
ADC1: J43.29; also elsewhere on the board
ADC2: J43.36; also elsewhere on the board
ADC3: J43.34; also elsewhere on the board
ADC4: J43.18; also elsewhere on the board
ADC5: J43.16; also elsewhere on the board
ADC6: J43.1; also elsewhere on the board
ADC7: J43.3; also elsewhere on the board
ADC12: J43.22; also elsewhere on the board
ADC13: J43.23; also elsewhere on the board
ADC14: J43.19; also elsewhere on the board
C1amped: J3.1, J4.1, J43.15
C2amped: J29.1, J30.1, J43.40
C3amped: J43.20
C4amped: J43.2
F1: J24.1, J43.13
F2: J25.1, J43.35
F3: J33.1, J43.37
F4: J34.1, J43.30
F5: J5.1, J43.10
F6: J6.1, J43.26
F7: J31.1, J43.11
F8: J32.1, J43.6
GND: J7.1, J8.1, J11.1, J12.1, J13.1, J14.1, J19.1, J35.1, J36.1, J37.1, J38.1, J43.8, J43.9, J43.28, J43.33; also elsewhere on the board
LMIN0: J17.1, R1.1; also elsewhere on the board
LMIN1: J16.1, R3.1; also elsewhere on the board
LMIN2: J42.1, R9.1; also elsewhere on the board
LMIN3: J41.1, R11.1; also elsewhere on the board
LMIN4: J10.1, R2.1; also elsewhere on the board
LMIN5: J9.1, R4.1; also elsewhere on the board
LMIN6: J40.1, R8.1; also elsewhere on the board
LMIN7: J39.1, R10.1; also elsewhere on the board
LMIN8: J18.1, R5.1; also elsewhere on the board
LMIN9: J15.1, R6.1; also elsewhere on the board
LMIN10: J22.1, R7.1; also elsewhere on the board
unnamed: C1.1, R1.2
unnamed: C2.1, R2.2
unnamed: C3.1, R3.2
unnamed: C4.1, R4.2
unnamed: C5.1, R5.2
unnamed: C6.1, R6.2
unnamed: C7.1, R7.2
unnamed: C8.1, R8.2
unnamed: C9.1, R9.2
unnamed: C10.1, R10.2
unnamed: C11.1, R11.2
PWM1amped: C1.2, C3.2, J43.38
PWM2amped: C9.2, C11.2, J43.24
PWM3amped: C2.2, C4.2, J43.14
PWM4amped: C8.2, C10.2, J43.17
PWMxamped: C5.2, C6.2, C7.2, J43.32
TRIG: J1.1, J2.1, J20.1, J21.1, J23.1, J26.1, J27.1, J28.1
TRIGG: J43.25

Notes on the sheet:
[3]
[4]
For central control x3
NEW: 4 sections x3 LM circuit, PWM goes via 10nF and 47k to pad, to LM circuit and then to ADCx
[2]
[1]
Add 3x inner ADC also - what is their PWM - PWMx?

Parts:
C12, C13, C14, C18, C19, C20, C32, C33, C34, C35, C36: 1nF; C_0805_2012Metric
C15, C16, C17, C21, C22, C23, C27, C28, C29, C30, C31: 22pF; C_0805_2012Metric
C24, C25, C26: 100nF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33: 1N914; D_SOD-123
R12, R13, R14, R21, R22, R23, R49, R50, R51, R54, R55: 4M7; R_0805_2012Metric
R15, R16, R17, R24, R25, R26, R42, R43, R45, R46, R48: 47K; R_0805_2012Metric
R18, R19, R20, R27, R28, R29, R41, R44, R47, R52, R53: 33K; R_0805_2012Metric
R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40: 22M; R_0805_2012Metric
U1, U2, U3: LM3900D; D14

Connections:
+12V: C24.2, C25.2, C26.2, U1.14 (VCC), U2.14 (VCC), U3.14 (VCC); also elsewhere on the board
ADC0: D11.1 (K), R28.2; also elsewhere on the board
ADC1: D10.1 (K), R19.2; also elsewhere on the board
ADC2: D24.1 (K), R44.2; also elsewhere on the board
ADC3: D23.1 (K), R52.2; also elsewhere on the board
ADC4: D17.1 (K), R29.2; also elsewhere on the board
ADC5: D16.1 (K), R20.2; also elsewhere on the board
ADC6: D30.1 (K), R47.2; also elsewhere on the board
ADC7: D29.1 (K), R53.2; also elsewhere on the board
ADC12: D5.1 (K), R27.2; also elsewhere on the board
ADC13: D4.1 (K), R18.2; also elsewhere on the board
ADC14: D19.1 (K), R41.2; also elsewhere on the board
GND: C24.1, C25.1, C26.1, R18.1, R19.1, R20.1, R27.1, R28.1, R29.1, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.1, R44.1, R47.1, R52.1, R53.1, U1.7 (GND), U2.7 (GND), U3.7 (GND); also elsewhere on the board
LMIN0: R25.1; also elsewhere on the board
LMIN1: R16.1; also elsewhere on the board
LMIN2: R45.1; also elsewhere on the board
LMIN3: R43.1; also elsewhere on the board
LMIN4: R26.1; also elsewhere on the board
LMIN5: R17.1; also elsewhere on the board
LMIN6: R48.1; also elsewhere on the board
LMIN7: R46.1; also elsewhere on the board
LMIN8: R24.1; also elsewhere on the board
LMIN9: R15.1; also elsewhere on the board
LMIN10: R42.1; also elsewhere on the board
unnamed: C12.1, D3.1 (K), R12.1, U1.3 (2IN-)
unnamed: C12.2, D4.2 (A), R12.2, U1.4 (2OUT)
unnamed: C13.1, D9.1 (K), R13.1, U2.3 (2IN-)
unnamed: C13.2, D10.2 (A), R13.2, U2.4 (2OUT)
unnamed: C14.1, D15.1 (K), R14.1, U3.3 (2IN-)
unnamed: C14.2, D16.2 (A), R14.2, U3.4 (2OUT)
unnamed: C15.1, R15.2
unnamed: C15.2, D2.1 (K), D3.2 (A)
unnamed: C16.1, R16.2
unnamed: C16.2, D8.1 (K), D9.2 (A)
unnamed: C17.1, R17.2
unnamed: C17.2, D14.1 (K), D15.2 (A)
unnamed: C18.1, D5.2 (A), R21.1, U1.5 (1OUT)
unnamed: C18.2, D6.1 (K), R21.2, U1.6 (1IN-)
unnamed: C19.1, D11.2 (A), R22.1, U2.5 (1OUT)
unnamed: C19.2, D12.1 (K), R22.2, U2.6 (1IN-)
unnamed: C20.1, D17.2 (A), R23.1, U3.5 (1OUT)
unnamed: C20.2, D18.1 (K), R23.2, U3.6 (1IN-)
unnamed: C21.1, R24.2
unnamed: C21.2, D1.1 (K), D6.2 (A)
unnamed: C22.1, R25.2
unnamed: C22.2, D7.1 (K), D12.2 (A)
unnamed: C23.1, R26.2
unnamed: C23.2, D13.1 (K), D18.2 (A)
unnamed: C27.1, R42.2
unnamed: C27.2, D20.2 (A), D21.1 (K)
unnamed: C28.1, R43.2
unnamed: C28.2, D22.2 (A), D27.1 (K)
unnamed: C29.1, R45.2
unnamed: C29.2, D25.2 (A), D26.1 (K)
unnamed: C30.1, R46.2
unnamed: C30.2, D28.2 (A), D33.1 (K)
unnamed: C31.1, R48.2
unnamed: C31.2, D31.2 (A), D32.1 (K)
unnamed: C32.1, D19.2 (A), R49.1, U1.9 (3OUT)
unnamed: C32.2, D20.1 (K), R49.2, U1.8 (3IN-)
unnamed: C33.1, D24.2 (A), R50.1, U2.9 (3OUT)
unnamed: C33.2, D25.1 (K), R50.2, U2.8 (3IN-)
unnamed: C34.1, D30.2 (A), R51.1, U3.9 (3OUT)
unnamed: C34.2, D31.1 (K), R51.2, U3.8 (3IN-)
unnamed: C35.1, D23.2 (A), R54.1, U2.10 (4OUT)
unnamed: C35.2, D22.1 (K), R54.2, U2.11 (IN4-)
unnamed: C36.1, D29.2 (A), R55.1, U3.10 (4OUT)
unnamed: C36.2, D28.1 (K), R55.2, U3.11 (IN4-)
unnamed: D1.2 (A), R31.1, U1.1 (1IN+)
unnamed: D2.2 (A), R30.1, U1.2 (2IN+)
unnamed: D7.2 (A), R33.1, U2.1 (1IN+)
unnamed: D8.2 (A), R32.1, U2.2 (2IN+)
unnamed: D13.2 (A), R35.1, U3.1 (1IN+)
unnamed: D14.2 (A), R34.1, U3.2 (2IN+)
unnamed: D21.2 (A), R36.1, U1.13 (3IN+)
unnamed: D26.2 (A), R38.1, U2.13 (3IN+)
unnamed: D27.2 (A), R37.1, U2.12 (4IN+)
unnamed: D32.2 (A), R40.1, U3.13 (3IN+)
unnamed: D33.2 (A), R39.1, U3.12 (4IN+)

Board: 2 copper layers, 101.3 x 128.4 mm, 170 parts (128 on the bottom side), 107 nets.

## KiCad design pyro000_PCB/pyro000_kicad.kicad_pcb

Parts:
C1, C5, C7, C8, C9, C11, C14: 100nF; C_0805_2012Metric; LCSC C49678
C6: 1uF; C_0805_2012Metric; LCSC C1953188
C12, C13: 22pF; C_0805_2012Metric; LCSC C1804
D3, D4, D5, D6: BAT54S; SOT-23; LCSC C8592
D7, D8, D9, D10: LED; LED_0805_2012Metric; LCSC C2827267
J2: PROG; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_02x04_Top_Bottom; Push_terminals_2x4_Cliff_FE6930
J4: Barrel_Jack_Switch; BARREL_JACK
M1, M2, M3, M4: AUDIO-JACKERTHENVAR-PJ398-allcolours-rescue; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHolesKEEPOUT
Q1, Q2, Q3, Q4: IRLB8721PBF; TO-220-3_Horizontal_TabDown_DrainHeatSink
R1, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: 10K; R_0805_2012Metric; LCSC C17414
R2: 1K; R_0805_2012Metric; LCSC C17513
R20, R21, R22, R23: 220R; R_0805_2012Metric; LCSC C114519
R24, R25, R26, R27, R28: 100K; R_0805_2012Metric; LCSC C149504
SW1: PEC11R-4215F-S0024; XDCR_PEC11R-4215F-S0024
U2: ATmega168-20A; TQFP-32_7x7mm_P0.8mm; LCSC C8728
Y1: Crystal; Crystal_SMD_HC49-SD

Connections:
+5V: C6.1, C7.1, C8.1, D3.2, D4.2, D5.2, D6.2, R3.1, R4.1, R5.2, R6.2, U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC); also elsewhere on the board
/APULSOUT0: Q2.1 (G), R17.1, U2.30 (PD0)
/APULSOUT1: Q3.1 (G), R18.1, U2.31 (PD1)
/APULSOUT2: Q1.1 (G), R16.1, U2.13 (PB1)
/APULSOUT3: Q4.1 (G), R19.1, U2.14 (PB2)
/AVRPULSIN0: R13.2, R26.2, U2.23 (PC0)
/AVRPULSIN1: R14.2, R27.2, U2.24 (PC1)
/AVRPULSIN2: R12.2, R25.2, U2.25 (PC2)
/AVRPULSIN3: R15.2, R28.2, U2.26 (PC3)
/ENC0: C9.1, R1.1, U2.32 (PD2)
/ENC1: C14.1, R7.2, U2.1 (PD3)
/LED0: R21.1, U2.2 (PD4)
/LED1: R22.1, U2.9 (PD5)
/LED2: R20.1, U2.10 (PD6)
/LED3: R23.1, U2.11 (PD7)
/MISO: J2.3, U2.16 (PB4)
/MOSI: J2.2, U2.15 (PB3)
/POWER: J3.5, J3.6, J3.7, J3.8, J4.1
/PULL0: J3.1, Q2.2 (D)
/PULL1: J3.2, Q3.2 (D)
/PULL2: J3.3, Q1.2 (D)
/PULL3: J3.4, Q4.2 (D)
/PULSIN0: M2.3 (TIP), R9.2
/PULSIN1: M3.3 (TIP), R10.2
/PULSIN2: M1.3 (TIP), R8.2
/PULSIN3: M4.3 (TIP), R11.2
/RESET: C11.1, J2.1, R6.1, U2.29 (~RESET/PC6)
/SCK: J2.4, U2.17 (PB5)
/SW: C1.1, R2.1, R24.2, U2.12 (PB0)
GND: C1.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.1, C13.1, C14.2, D3.1, D4.1, D5.1, D6.1, D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J2.5, J4.2, M1.1 (RING), M1.2 (NORM), M2.1 (RING), M2.2 (NORM), M3.1 (RING), M3.2 (NORM), M4.1 (RING), M4.2 (NORM), Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), R16.2, R17.2, R18.2, R19.2, R24.1, R25.1, R26.1, R27.1, R28.1, SW1.C, U2.3 (GND), U2.5 (GND), U2.21 (GND); also elsewhere on the board
unnamed: C5.1, U2.20 (AREF)
unnamed: C12.2, U2.7 (XTAL1/PB6), Y1.2
unnamed: C13.2, U2.8 (XTAL2/PB7), Y1.1
unnamed: D3.3, R8.1, R12.1
unnamed: D4.3, R9.1, R13.1
unnamed: D5.3, R10.1, R14.1
unnamed: D6.3, R11.1, R15.1
unnamed: D7.2 (A), R20.2
unnamed: D8.2 (A), R21.2
unnamed: D9.2 (A), R22.2
unnamed: D10.2 (A), R23.2
unnamed: R1.2, R3.2, SW1.B
unnamed: R2.2, SW1.S2
unnamed: R4.2, R7.1, SW1.A
unnamed: R5.1, SW1.S1

Notes on the sheet:
- 10k pulldown on gates of FET - switch on encoder as arming? - LED? to show ready??? - power socket (as in BREATH)

Parts:
C2, C3: 10uF; CP_EIA-3216-18_Kemet-A
C4: 100nF; C_0805_2012Metric
D2: D; D_SOD-123
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
U1: LM1117-5.0; TO-252-2

Connections:
+5V: C3.1, C4.1, U1.2 (VO); also elsewhere on the board
+12V: C2.1, D2.1 (K), U1.3 (VI)
GND: C2.2, C3.2, C4.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, U1.1 (GND); also elsewhere on the board
unnamed: D2.2 (A), J1.1, J1.2

Notes on the sheet:
euro_conn

Board: 2 copper layers, 50.0 x 106.0 mm, 66 parts (55 on the bottom side), 47 nets.
