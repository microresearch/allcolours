# Repository microresearch/allcolours (continued)

## KiCad design touch_toggle_final/touch_toggle_latest_ADG/touch_toggle_latest_ADG.kicad_pcb

Parts:
C1, C2: 10u; CP_EIA-3216-18_Kemet-A
C3: 10u; CP_EIA-3216-18_Kemet-A; LCSC C1952791
C4: 100N; C_0805_2012Metric; LCSC C49678
C5, C6, C7, C8, C9, C10: 100NF; C_0805_2012Metric; LCSC C49678
D1, D2: 1N5819; D_SOD-123; LCSC C82544
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
M1, M2, M3, M4, M5, M6, M7, M8: AUDIO-JACKERTHENVAR-PJ398; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
P1: CONN_02X05; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4: 4.7M; R_0805_2012Metric; LCSC C17674
R5, R6, R7, R8, R9, R10, R11, R12: 1K; R_0805_2012Metric; LCSC C17513
R13, R14, R15, R16: 22K; R_0805_2012Metric; LCSC C17560
U1: LM1117-5.0; TO-252-2; LCSC C129952
U2: 40106; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C38184
U3, U4: 4013; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C194333
U5: ADG412BNZ; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C3.1, C4.1, C5.2, C6.2, C7.2, C8.2, R1.1, R2.1, R3.1, R4.1, U1.2 (VO), U2.14 (VDD), U3.14 (VDD), U4.14 (VDD), U5.12 (VL)
+12V: C1.1, C9.2, D2.1 (K), U1.3 (VI), U5.13 (VDD)
-12V: C2.2, C10.2, D1.2 (A), U5.4 (VSS)
/IN1: M4.3 (TIP), U5.3 (S1)
/IN2: M3.3 (TIP), U5.14 (S2)
/IN3: M2.3 (TIP), U5.11 (S3)
/IN4: M1.3 (TIP), U5.6 (S4)
/OUT1: M8.3 (TIP), U5.2 (D1)
/OUT2: M7.3 (TIP), U5.15 (D2)
/OUT3: M6.3 (TIP), U5.10 (D3)
/OUT4: M5.3 (TIP), U5.7 (D4)
/S1: R11.1, R15.2, U5.1 (IN1)
/S2: R9.1, R13.2, U5.16 (IN2)
/S3: R12.1, R16.2, U5.9 (IN3)
/S4: R10.1, R14.2, U5.8 (IN4)
/SW1: J1.1, R3.2, U2.1
/SW2: J1.3, R1.2, U2.3
/SW3: J1.4, R4.2, U2.5
/SW4: J1.2, R2.2, U2.9
GND: C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, J1.5, J1.6, M1.1 (RING), M2.1 (RING), M3.1 (RING), M4.1 (RING), M5.1 (RING), M6.1 (RING), M7.1 (RING), M8.1 (RING), P1.3, P1.4, P1.5, P1.6, P1.7, P1.8, R13.1, R14.1, R15.1, R16.1, U1.1 (GND), U2.7 (VSS), U3.4 (R), U3.6 (S), U3.7 (VSS), U3.8 (S), U3.10 (R), U4.4 (R), U4.6 (S), U4.7 (VSS), U4.8 (S), U4.10 (R), U5.5 (GND)
unnamed: D1.1 (K), P1.9, P1.10
unnamed: D2.2 (A), P1.1, P1.2
unnamed: R5.1, U3.11 (C)
unnamed: R5.2, U2.4
unnamed: R6.1, U4.11 (C)
unnamed: R6.2, U2.8
unnamed: R7.1, U3.3 (C)
unnamed: R7.2, U2.2
unnamed: R8.1, U4.3 (C)
unnamed: R8.2, U2.6
unnamed: R9.2, U3.13 (Q)
unnamed: R10.2, U4.13 (Q)
unnamed: R11.2, U3.1 (Q)
unnamed: R12.2, U4.1 (Q)
unnamed: U3.2 (~Q), U3.5 (D)
unnamed: U3.9 (D), U3.12 (~Q)
unnamed: U4.2 (~Q), U4.5 (D)
unnamed: U4.9 (D), U4.12 (~Q)

Notes on the sheet:
euro_conn
Euro connector at lower/mid right side (from front of pcb, so left on back) above jacks.
PCB size is for 8hp panel: so 40mm x 107mm - all parts on front facing panel then... watch keep out zone for jacks
two rows of PJ398SM jacks at bottom of the pcb/panel - lowest row as close as possible to edge of PCB
6 pin connector can be above jacks - between jacks and mid of pcb

Board: 2 copper layers, 40.0 x 107.0 mm, 43 parts (0 on the bottom side), 38 nets.

## KiCad design comparator_v2/comparator.kicad_pcb

Parts:
C3, C4, C5, C6: 100N; C_0805_2012Metric; LCSC C49678
C7, C8, C9, C10, C11, C12: 100NF; C_0805_2012Metric; LCSC C49678
D3, D4, D5, D6: 1N4148; D_SOD-123; LCSC C81598
R1, R3, R5, R7, R8, R11, R12, R13, R15, R19, R20, R21: 10K; R_0805_2012Metric; LCSC C17414
R2, R4, R6, R9, R33, R34, R35, R36: 100K; R_0805_2012Metric; LCSC C149504
R10, R14, R16, R17, R18, R22, R23, R24: 10k; R_0805_2012Metric; LCSC C17414
R25, R27, R28, R29, R37, R38, R39, R40: 1K; R_0805_2012Metric; LCSC C17513
R26, R30, R31, R32: 1.2K; R_0805_2012Metric; LCSC C103946
RV1, RV2, RV3, RV4: 10K; Potentiometer_Alps-RK09
U2, U3: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594
U4, U5: ADG413BNZ; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C7.2, C8.2, U4.12 (VL), U5.12 (VL); also elsewhere on the board
-12V: C4.2, C6.2, C11.2, C12.2, R16.1, R22.1, R23.1, R24.1, U2.11 (V-), U3.11 (V-), U4.4 (VSS), U5.4 (VSS); also elsewhere on the board
/C1SWOUT: R33.2, U3.3 (+), U4.3 (S1), U4.14 (S2)
/C2SWOUT: R35.2, U3.5 (+), U4.6 (S4), U4.11 (S3)
/C3SWOUT: R34.2, U3.10 (+), U5.3 (S1), U5.14 (S2)
/C4SWOUT: R36.2, U3.12 (+), U5.6 (S4), U5.11 (S3)
COMP1_IN1: R2.2, R8.2; also elsewhere on the board
COMP1_IN2: R1.2; also elsewhere on the board
COMP1_OUT: R25.1, R26.2, U4.1 (IN1), U4.16 (IN2); also elsewhere on the board
COMP1_SWIN1: U4.2 (D1); also elsewhere on the board
COMP1_SWIN2: U4.15 (D2); also elsewhere on the board
COMP1_SWOUT: R37.1; also elsewhere on the board
COMP2_IN1: R4.2, R11.2; also elsewhere on the board
COMP2_IN2: R3.2; also elsewhere on the board
COMP2_OUT: R27.1, R30.2, U4.8 (IN4), U4.9 (IN3); also elsewhere on the board
COMP2_SWIN1: U4.10 (D3); also elsewhere on the board
COMP2_SWIN2: U4.7 (D4); also elsewhere on the board
COMP2_SWOUT: R39.1; also elsewhere on the board
COMP3_IN1: R9.2, R15.2; also elsewhere on the board
COMP3_IN2: R7.2; also elsewhere on the board
COMP3_OUT: R29.1, R32.2, U5.1 (IN1), U5.16 (IN2); also elsewhere on the board
COMP3_SWIN1: U5.2 (D1); also elsewhere on the board
COMP3_SWIN2: U5.15 (D2); also elsewhere on the board
COMP3_SWOUT: R38.1; also elsewhere on the board
COMP4_IN1: R6.2, R13.2; also elsewhere on the board
COMP4_IN2: R5.2; also elsewhere on the board
COMP4_OUT: R28.1, R31.2, U5.8 (IN4), U5.9 (IN3); also elsewhere on the board
COMP4_SWIN1: U5.10 (D3); also elsewhere on the board
COMP4_SWIN2: U5.7 (D4); also elsewhere on the board
COMP4_SWOUT: R40.1; also elsewhere on the board
GND: C3.2, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, R2.1, R4.1, R6.1, R9.1, R26.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, U4.5 (GND), U5.5 (GND); also elsewhere on the board
unnamed: D3.1 (K), R25.2
unnamed: D3.2 (A), U2.1
unnamed: D4.1 (K), R27.2
unnamed: D4.2 (A), U2.7
unnamed: D5.1 (K), R28.2
unnamed: D5.2 (A), U2.14
unnamed: D6.1 (K), R29.2
unnamed: D6.2 (A), U2.8
unnamed: R1.1, R12.2, U2.2 (-)
unnamed: R8.1, U2.3 (+)
unnamed: R10.2, RV1.1
unnamed: R11.1, U2.5 (+)
unnamed: R12.1, RV1.2
unnamed: R13.1, U2.12 (+)
unnamed: R14.2, RV2.1
unnamed: R15.1, U2.10 (+)
unnamed: R16.2, RV1.3
unnamed: R17.2, RV4.1
unnamed: R18.2, RV3.1
unnamed: R19.1, RV2.2
unnamed: R3.1, R19.2, U2.6 (-)
unnamed: R20.1, RV4.2
unnamed: R5.1, R20.2, U2.13 (-)
unnamed: R21.1, RV3.2
unnamed: R7.1, R21.2, U2.9 (-)
unnamed: R22.2, RV2.3
unnamed: R23.2, RV4.3
unnamed: R24.2, RV3.3
unnamed: R37.2, U3.1, U3.2 (-)
unnamed: R38.2, U3.8, U3.9 (-)
unnamed: R39.2, U3.6 (-), U3.7
unnamed: R40.2, U3.13 (-), U3.14

Notes on the sheet:
IN1 and IN4 close on logic 1 IN2 and IN3 open so can be used as SPDT
values can change!
4x comparator and switch module: 12HP=128.5x60.6mm (base PCB as slightly smaller: 106x60mm)
1k-1.2k 11/8/2023
SWOUT buffered

Parts:
M1, M2, M3, M4, M5, M6, M7, M8, M9, M10, M11, M12, M13, M14, M15, M16, M17, M18, M19, M20, M21, M22, M23, M24: AUDIO-JACKERTHENVAR-PJ398; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHolesKEEPOUT
R41, R42, R43, R44: 10K; R_0805_2012Metric

Connections:
COMP1_BOUT: R42.1; also elsewhere on the board
COMP1_IN1: M5.3 (TIP), M7.2 (NORM), M9.2 (NORM); also elsewhere on the board
COMP1_IN2: M6.3 (TIP); also elsewhere on the board
COMP1_OUT: M17.3 (TIP); also elsewhere on the board
COMP1_SWIN1: M13.3 (TIP); also elsewhere on the board
COMP1_SWIN2: M14.3 (TIP); also elsewhere on the board
COMP1_SWOUT: M1.3 (TIP); also elsewhere on the board
COMP2_BOUT: R41.1; also elsewhere on the board
COMP2_IN1: M7.3 (TIP); also elsewhere on the board
COMP2_IN2: M8.3 (TIP); also elsewhere on the board
COMP2_OUT: M18.3 (TIP); also elsewhere on the board
COMP2_SWIN1: M15.3 (TIP); also elsewhere on the board
COMP2_SWIN2: M16.3 (TIP); also elsewhere on the board
COMP2_SWOUT: M2.3 (TIP); also elsewhere on the board
COMP3_BOUT: R43.1; also elsewhere on the board
COMP3_IN1: M9.3 (TIP), M11.2 (NORM); also elsewhere on the board
COMP3_IN2: M10.3 (TIP); also elsewhere on the board
COMP3_OUT: M19.3 (TIP); also elsewhere on the board
COMP3_SWIN1: M21.3 (TIP); also elsewhere on the board
COMP3_SWIN2: M22.3 (TIP); also elsewhere on the board
COMP3_SWOUT: M3.3 (TIP); also elsewhere on the board
COMP4_BOUT: R44.1; also elsewhere on the board
COMP4_IN1: M11.3 (TIP); also elsewhere on the board
COMP4_IN2: M12.3 (TIP); also elsewhere on the board
COMP4_OUT: M20.3 (TIP); also elsewhere on the board
COMP4_SWIN1: M23.3 (TIP); also elsewhere on the board
COMP4_SWIN2: M24.3 (TIP); also elsewhere on the board
COMP4_SWOUT: M4.3 (TIP); also elsewhere on the board
GND: M1.1@1 (RING), M1.1@2 (RING), M2.1@1 (RING), M2.1@2 (RING), M3.1@1 (RING), M3.1@2 (RING), M4.1@1 (RING), M4.1@2 (RING), M5.1@1 (RING), M5.1@2 (RING), M6.1@1 (RING), M6.1@2 (RING), M7.1@1 (RING), M7.1@2 (RING), M8.1@1 (RING), M8.1@2 (RING), M9.1@1 (RING), M9.1@2 (RING), M10.1@1 (RING), M10.1@2 (RING), M11.1@1 (RING), M11.1@2 (RING), M12.1@1 (RING), M12.1@2 (RING), M13.1@1 (RING), M13.1@2 (RING), M14.1@1 (RING), M14.1@2 (RING), M14.2 (NORM), M15.1@1 (RING), M15.1@2 (RING), M16.1@1 (RING), M16.1@2 (RING), M16.2 (NORM), M17.1@1 (RING), M17.1@2 (RING), M18.1@1 (RING), M18.1@2 (RING), M19.1@1 (RING), M19.1@2 (RING), M20.1@1 (RING), M20.1@2 (RING), M21.1@1 (RING), M21.1@2 (RING), M22.1@1 (RING), M22.1@2 (RING), M22.2 (NORM), M23.1@1 (RING), M23.1@2 (RING), M24.1@1 (RING), M24.1@2 (RING), M24.2 (NORM); also elsewhere on the board
unnamed: M13.2 (NORM), R42.2
unnamed: M15.2 (NORM), R41.2
unnamed: M21.2 (NORM), R43.2
unnamed: M23.2 (NORM), R44.2

Notes on the sheet:
24 jacks total!
4x switch out, 8x switch in
8x comp in, 4x comp out
Layout in 4 sections: O O compx_in1 compx_swin1 O (POT) O = compx_out POTx compx_swout O O compx_in2 compx_swin2

Parts:
C1, C2, C13: 10u; CP_EIA-3216-18_Kemet-A
C14: 100N; C_0805_2012Metric
D1, D2: 1N5819; D_SOD-123
P1: CONN_02X05; PinHeader_2x05_P2.54mm_Vertical
U6: LM1117-5.0; TO-252-2

Connections:
+5V: C13.1, C14.1, U6.2 (VO); also elsewhere on the board
-12V: C2.2, D1.2 (A); also elsewhere on the board
GND: C1.2, C2.1, C13.2, C14.2, P1.3, P1.4, P1.5, P1.6, P1.7, P1.8, U6.1 (GND); also elsewhere on the board
unnamed: D1.1 (K), P1.9, P1.10
unnamed: D2.2 (A), P1.1, P1.2

Notes on the sheet:
euro_conn

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
Board: 2 copper layers, 60.0 x 106.0 mm, 105 parts (77 on the bottom side), 78 nets.

Other parts of the board:
C15, C16: 100N; C_0805_2012Metric
R45, R46, R47, R48: 1K; R_0805_2012Metric
U1: TL074; SOIC-14_3.9x8.7mm_P1.27mm

Their connections:
-12V: C16.2, U1.11 (V-); also elsewhere on the board
COMP1_BOUT: U1.1, U1.2 (-); also elsewhere on the board
COMP1_IN1: R47.1; also elsewhere on the board
COMP2_BOUT: U1.6 (-), U1.7; also elsewhere on the board
COMP2_IN1: R48.1; also elsewhere on the board
COMP3_BOUT: U1.8, U1.9 (-); also elsewhere on the board
COMP3_IN1: R46.1; also elsewhere on the board
COMP4_BOUT: U1.13 (-), U1.14; also elsewhere on the board
COMP4_IN1: R45.1; also elsewhere on the board
GND: C15.2, C16.1; also elsewhere on the board
unnamed: R45.2, U1.12 (+)
unnamed: R46.2, U1.10 (+)
unnamed: R47.2, U1.3 (+)
unnamed: R48.2, U1.5 (+)

## KiCad design touch_toggle_final/touch_toggle_latest_panel/latest_panel_kicad/latest_panel_kicad.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6: Conn_01x01_Male; TestPoint_Pad_1.5x1.5mm
J7: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical_SMD

Connections:
/SW1: J6.1, J7.2
/SW2: J4.1, J7.4
/SW3: J5.1, J7.3
/SW4: J3.1, J7.1
GND: J1.1, J2.1, J7.5, J7.6

Notes on the sheet:
Front panel for touch_toggle (sulphur): - size of panel is 128.5 x 40.3mm (back pcb is central to this one vertically) - 4x 3.2mm plated throughhole (3.4mm pad) to mount panel as indicated on https://doepfer.de/a100_man/a100m_e.htm - SMD 6 pin connector on back of panel matches up with connector on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
mirrored so matches pcb facing it

Board: 2 copper layers, 40.3 x 128.5 mm, 7 parts (1 on the bottom side), 5 nets.
