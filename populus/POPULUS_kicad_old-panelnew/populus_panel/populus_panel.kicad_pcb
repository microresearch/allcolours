# Repository microresearch/allcolours

## KiCad design populus/POPULUS_kicad_old-panelnew/populus_panel/populus_panel.kicad_pcb

Board: 2 copper layers, 141.8 x 128.5 mm, 78 parts (11 on the bottom side), 64 nets.

Parts:
0K, 0K#2, 0K#3, 0K#4, 0K#5, 0K#6, 0K#7, 0K#8, 0K#9: R_0805_2012Metric
J1: Conn_02x12_Odd_Even; PinHeader_2x12_P2.54mm_Vertical_SMD
J2, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45, J47, J48, J49, J50, J51, J52, J53, J54, J55, J56, J57, J58, J59, J60, J61, J62, J63, J64, J65, J66, J67, J68, J69, J70: Conn_01x01_Pin; TestPoint_Pad_1.0x1.0mm_nosilk
J3: Conn_02x18_Odd_Even; PinHeader_2x22_P2.54mm_Vertical_SMD

Connections:
/In1: J2.1, J3.1
/In2: J3.3, J4.1
/In3: J3.5, J5.1
/In4: 0K.1, 0K.2, 0K#2.1, 0K#2.2, 0K#8.1, 0K#8.2, J3.7, J6.1
/In5: 0K#6.1, 0K#6.2, 0K#7.1, 0K#7.2, 0K#9.1, 0K#9.2, J3.9, J7.1
/In6: J3.11, J8.1
/In7: J3.13, J9.1
/OutA: J3.2, J45.1
/OutB: J3.4, J44.1
/OutC: J3.6, J43.1
/OutD: J3.8, J42.1
/OutE: J3.10, J41.1
/OutF: J3.12, J40.1
/OutG: J3.14, J39.1
/SW_A1: J3.15, J10.1
/SW_A2: J3.17, J11.1
/SW_A3: J3.16, J38.1
/SW_A4: J3.18, J37.1
/SW_A5: J3.19, J12.1
/SW_A6: J3.21, J13.1
/SW_A7: 0K#3.1, 0K#3.2, 0K#4.1, 0K#4.2, 0K#5.1, 0K#5.2, J3.20, J36.1
/SW_B1: J3.22, J35.1
/SW_B2: J3.24, J34.1
/SW_B3: J3.23, J14.1
/SW_B4: J3.25, J15.1
/SW_B5: J3.26, J33.1
/SW_B6: J3.28, J32.1
/SW_B7: J3.27, J16.1
/SW_C1: J3.30, J31.1
/SW_C2: J3.32, J30.1
/SW_C3: J3.29, J17.1
/SW_C4: J3.31, J18.1
/SW_C5: J3.34, J29.1
/SW_C6: J3.36, J28.1
/SW_C7: J3.33, J19.1
/SW_D1: J3.35, J20.1
/SW_D2: J3.37, J21.1
/SW_D3: J3.38, J27.1
/SW_D4: J3.40, J26.1
/SW_D5: J3.39, J22.1
/SW_D6: J3.41, J23.1
/SW_D7: J3.42, J25.1
/SW_E1: J1.2, J70.1
/SW_E2: J1.4, J69.1
/SW_E3: J1.1, J47.1
/SW_E4: J1.3, J48.1
/SW_E5: J1.6, J68.1
/SW_E6: J1.8, J67.1
/SW_E7: J1.5, J49.1
/SW_F1: J1.7, J50.1
/SW_F2: J1.9, J51.1
/SW_F3: J1.10, J66.1
/SW_F4: J1.12, J65.1
/SW_F5: J1.11, J52.1
/SW_F6: J1.13, J53.1
/SW_F7: J1.14, J64.1
/SW_G1: J1.16, J63.1
/SW_G2: J1.18, J62.1
/SW_G3: J1.15, J54.1
/SW_G4: J1.17, J55.1
/SW_G5: J1.20, J61.1
/SW_G6: J1.22, J60.1
/SW_G7: J1.19, J56.1
GND: J1.21, J1.23, J1.24, J3.43, J3.44, J24.1, J57.1, J58.1, J59.1

## KiCad design touch/touch_kicad_new2024/touch.kicad_pcb

Notes on the sheet:
Notes: that frozen levels are saved to a stack and can be popped off the stack, various over-rides...

Parts:
C1, C2, C3, C5, C7: 10uF; SMD-1206_Pol
C4, C6, C8: 100nF; C_0805_2012Metric
D1, D2: D; D_SOD-123
J1: Conn_02x05_Odd_Even; Pin_Header_Straight_2x05_Pitch2.54mm
L1: INDUCTOR; R_0603
U1: LM1117-5.0; TO-252-2
U2: LM1117-3.3; TO-252-2

Connections:
5volts: C3.1, C4.1, U1.2 (VO), U2.3 (VI)
+3.3V: C5.1, C6.1, L1.1, U2.2 (VO); also elsewhere on the board
+3.3VA: C7.1, C8.1, L1.2; also elsewhere on the board
+12V: C2.1, D2.1 (K), U1.3 (VI); also elsewhere on the board
-12V: C1.2, D1.2 (A); also elsewhere on the board
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, U1.1 (GND), U2.1 (GND); also elsewhere on the board
unnamed: D1.1 (K), J1.9, J1.10
unnamed: D2.2 (A), J1.1, J1.2

Notes on the sheet:
euro_conn

Parts:
C9, C10, C11, C12, C13, C14, C15, C16: 1NF; C_0805_2012Metric
C49, C50, C51, C52: 100nF; C_0805_2012Metric
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70: 1K; R_0805_2012Metric
U3, U4: TL074; SOIC-14_3.9x8.7mm_Pitch1.27mm
U6: 4051; SOIC-16_3.9x9.9mm_Pitch1.27mm

Connections:
+3.3V: U6.16 (VDD); also elsewhere on the board
+12V: C49.1, C50.1, U3.4 (V+), U4.4 (V+); also elsewhere on the board
-12V: C51.1, C52.1, U3.11 (V-), U4.11 (V-); also elsewhere on the board
DAC: U6.3 (X); also elsewhere on the board
DAC1: C11.1, U4.3 (+), U6.13 (X0)
DAC2: C13.1, U3.5 (+), U6.14 (X1)
DAC3: C12.1, U4.10 (+), U6.15 (X2)
DAC4: C14.1, U3.12 (+), U6.12 (X3)
DAC5: C9.1, U3.3 (+), U6.1 (X4)
DAC6: C15.1, U4.5 (+), U6.5 (X5)
DAC7: C10.1, U4.12 (+), U6.2 (X6)
DAC8: C16.1, U3.10 (+), U6.4 (X7)
EN_LOW1: U6.6 (Inh); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C49.2, C50.2, C51.2, C52.2, R1.1, R4.1, R7.1, R8.1, R61.1, R63.1, R64.1, R66.1, U6.7 (VEE), U6.8 (VSS); also elsewhere on the board
unnamed: R1.2, R2.2, U3.2 (-)
unnamed: R2.1, R3.2, U3.1
unnamed: R4.2, R5.2, U4.6 (-)
unnamed: R5.1, R9.2, U4.7
unnamed: R6.2, R62.1, U4.14
unnamed: R10.1, R59.2, U4.1
unnamed: R7.2, R10.2, U4.2 (-)
unnamed: R11.1, R60.2, U4.8
unnamed: R8.2, R11.2, U4.9 (-)
unnamed: R12.2, R65.1, U3.8
unnamed: R61.2, R62.2, U4.13 (-)
unnamed: R63.2, R67.2, U3.6 (-)
unnamed: R64.2, R65.2, U3.9 (-)
unnamed: R66.2, R68.2, U3.13 (-)
unnamed: R67.1, R69.2, U3.7
unnamed: R68.1, R70.2, U3.14
SEL1: U6.11 (A); also elsewhere on the board
SEL2: U6.10 (B); also elsewhere on the board
SEL3: U6.9 (C); also elsewhere on the board
v1: R3.1; also elsewhere on the board
v2: R9.1; also elsewhere on the board
v3: R6.1; also elsewhere on the board
v4: R12.1; also elsewhere on the board
x1: R59.1; also elsewhere on the board
x2: R69.1; also elsewhere on the board
x3: R60.1; also elsewhere on the board
x4: R70.1; also elsewhere on the board

Notes on the sheet:
sample and hold - amped x2 - tested
STM32F466 with internal DAC and multiplex this to sample/hold with 4051. 3 address lines for all, and enable line for each one. 4051 powered by 3.3v and sample/hold amp after is 2x amped 1k/1k!
changed from 47nf to 1nf 12/21

Parts:
C29, C30: 18pF; C_0805_2012Metric
C31, C33, C34, C35, C36, C37, C38: 100nF; C_0805_2012Metric
C32: 4.7uF; SMD-1206_Pol
D3, D4, D5, D6, D7, D8, D9, D10, D11, D13, D14, D15: BAT54S; SOT-23
J2: prog; Pin_Header_Straight_1x04_Pitch2.54mm
R71: 1k; R_0805_2012Metric
U11: STM32F413was446RETx; LQFP-64_10x10mm_Pitch0.5mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C34.1, C35.1, C36.1, C37.1, C38.1, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, D10.2, D11.2, D13.2, D14.2, D15.2, J2.4, U11.1 (VBAT), U11.19 (VDD), U11.32 (VDD), U11.48 (VDD), U11.64 (VDD); also elsewhere on the board
+3.3VA: C33.1, U11.13 (VDDA); also elsewhere on the board
/micro/SWCLK: J2.3, U11.49 (PA14)
/micro/SWDIO: J2.2, U11.46 (PA13)
ADC0: D4.3, U11.16 (PA2); also elsewhere on the board
ADC1: D6.3, U11.15 (PA1); also elsewhere on the board
ADC2: D8.3, U11.14 (PA0); also elsewhere on the board
ADC3: D10.3, U11.17 (PA3); also elsewhere on the board
ADC4: D5.3, U11.8 (PC0); also elsewhere on the board
ADC5: D7.3, U11.21 (PA5); also elsewhere on the board
ADC6: D9.3, U11.22 (PA6); also elsewhere on the board
ADC7: D11.3, U11.23 (PA7); also elsewhere on the board
ADC8: U11.10 (PC2); also elsewhere on the board
ADC9: U11.9 (PC1); also elsewhere on the board
ADC10: U11.26 (PB0); also elsewhere on the board
ADC11: U11.27 (PB1); also elsewhere on the board
ADC12: D13.3, U11.11 (PC3); also elsewhere on the board
ADC13: D14.3, U11.24 (PC4); also elsewhere on the board
ADC14: D15.3, U11.25 (PC5); also elsewhere on the board
DAC: U11.20 (PA4); also elsewhere on the board
EN_LOW1: U11.52 (PC11); also elsewhere on the board
FR1: U11.61 (PB8); also elsewhere on the board
FR2: U11.62 (PB9); also elsewhere on the board
FR3: U11.29 (PB10); also elsewhere on the board
FR4: U11.33 (PB12); also elsewhere on the board
FR5: U11.34 (PB13); also elsewhere on the board
FR6: U11.55 (PB3); also elsewhere on the board
FR7: U11.36 (PB15); also elsewhere on the board
FR8: U11.56 (PB4); also elsewhere on the board
GND: C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D13.1, D14.1, D15.1, J2.1, U11.12 (VSSA), U11.18 (VSS), U11.31 (VSS), U11.47 (VSS), U11.60 (BOOT0), U11.63 (VSS); also elsewhere on the board
unnamed: C29.1, U11.5 (PH0), Y1.2
unnamed: C30.1, U11.6 (PH1), Y1.1
unnamed: C31.1, U11.7 (NRST)
unnamed: C32.1, U11.30 (VCAP_1)
PWM1: U11.41 (PA8); also elsewhere on the board
PWM2: U11.35 (PB14); also elsewhere on the board
PWM3: U11.38 (PC7); also elsewhere on the board
PWM4: U11.59 (PB7); also elsewhere on the board
PWMx: U11.57 (PB5); also elsewhere on the board
SEL1: U11.2 (PC13); also elsewhere on the board
SEL2: U11.3 (PC14); also elsewhere on the board
SEL3: U11.4 (PC15); also elsewhere on the board
TRIG: D3.3, R71.2, U11.37 (PC6)
TRIGG: R71.1; also elsewhere on the board

Notes on the sheet:
adc4 not really so but makes easier
NOW with onboard DAC and less ADC and toggles (x12 needed)
17.5 - added OUT for trig surrounds to switch on/off

Parts:
R27, R28, R52, R53, R54, R55, R56, R57, R58, R78: 10K; R_0805_2012Metric
R93, R94, R99, R100: 1K; R_0805_2012Metric

Connections:
C1: R94.2; also elsewhere on the board
C1amped: R94.1; also elsewhere on the board
C2: R93.2; also elsewhere on the board
C2amped: R93.1; also elsewhere on the board
C3: R99.2; also elsewhere on the board
C3amped: R99.1; also elsewhere on the board
C4: R100.2; also elsewhere on the board
C4amped: R100.1; also elsewhere on the board
GND: R28.1, R52.1, R54.1, R56.1, R58.1; also elsewhere on the board
PWM1: R78.2; also elsewhere on the board
PWM1amped: R52.2, R78.1; also elsewhere on the board
PWM2: R55.2; also elsewhere on the board
PWM2amped: R55.1, R56.2; also elsewhere on the board
PWM3: R53.2; also elsewhere on the board
PWM3amped: R53.1, R54.2; also elsewhere on the board
PWM4: R57.2; also elsewhere on the board
PWM4amped: R57.1, R58.2; also elsewhere on the board
PWMx: R27.2; also elsewhere on the board
PWMxamped: R27.1, R28.2; also elsewhere on the board

Notes on the sheet:
PWM /2 = 1.6v out
removed amps + now just divider for PWM?

Parts:
D16: BAT54S; SOT-23
J4, J6: Conn_01x04_Male; Pin_Header_Straight_1x04_Pitch2.54mm
M2, M4, M6, M8, M9, M10, M11, M12, M13, M14, M15, M16: AUDIO-JACKERTHENVAR-PJ398; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
R26: 1K; R_0805_2012Metric

Connections:
+3.3V: D16.2; also elsewhere on the board
/IOjacks/nv1: J4.1, M12.2 (NORM)
/IOjacks/nv2: J4.3, M9.2 (NORM)
/IOjacks/nv3: J6.1, M14.2 (NORM)
/IOjacks/nv4: J6.3, M15.2 (NORM)
/IOjacks/nx1: J4.2, M11.2 (NORM)
/IOjacks/nx2: J4.4, M10.2 (NORM)
/IOjacks/nx3: J6.2, M13.2 (NORM)
/IOjacks/nx4: J6.4, M16.2 (NORM)
C1: M8.3 (TIP); also elsewhere on the board
C2: M6.3 (TIP); also elsewhere on the board
C3: M2.3 (TIP); also elsewhere on the board
C4: M4.3 (TIP); also elsewhere on the board
GND: D16.1, M2.1 (RING), M4.1 (RING), M6.1 (RING), M8.1 (RING), M9.1 (RING), M10.1 (RING), M11.1 (RING), M12.1 (RING), M13.1 (RING), M14.1 (RING), M15.1 (RING), M16.1 (RING); also elsewhere on the board
PWMXX: M2.2 (NORM), M4.2 (NORM), M6.2 (NORM), M8.2 (NORM), R26.1
PWMx: D16.3, R26.2; also elsewhere on the board
v1: M12.3 (TIP); also elsewhere on the board
v2: M9.3 (TIP); also elsewhere on the board
v3: M14.3 (TIP); also elsewhere on the board
v4: M15.3 (TIP); also elsewhere on the board
x1: M11.3 (TIP); also elsewhere on the board
x2: M10.3 (TIP); also elsewhere on the board
x3: M13.3 (TIP); also elsewhere on the board
x4: M16.3 (TIP); also elsewhere on the board

Notes on the sheet:
12x jacks
Added 4 pins norms for each I/O x4 22/4/2021 For each of 4 elements we have 4x jacks - A, B and C (out/feedback) and E which is voltage out!

Parts:
C65, C66: 100nF; C_0805_2012Metric
R29, R30, R31, R32, R33, R34, R41, R42, R43, R44, R45: 4.7M; R_0805_2012Metric
R35, R36, R37, R38, R39, R40, R47, R48, R49, R50, R51: 1K; R_0805_2012Metric
U13, U14: 40106; SOIC-14_3.9x8.7mm_Pitch1.27mm

Connections:
+3.3V: C65.1, C66.1, U13.14 (VDD), U14.14 (VDD); also elsewhere on the board
F1: R29.2, U13.1; also elsewhere on the board
F2: R30.2, U13.3; also elsewhere on the board
F3: R31.2, U13.5; also elsewhere on the board
F4: R32.2, U13.9; also elsewhere on the board
F5: R41.2, U14.1; also elsewhere on the board
F6: R42.2, U14.3; also elsewhere on the board
F7: R43.2, U14.5; also elsewhere on the board
F8: R44.2, U14.9; also elsewhere on the board
FR1: R35.1; also elsewhere on the board
FR2: R36.1; also elsewhere on the board
FR3: R51.1; also elsewhere on the board
FR4: R38.1; also elsewhere on the board
FR5: R47.1; also elsewhere on the board
FR6: R48.1; also elsewhere on the board
FR7: R49.1; also elsewhere on the board
FR8: R50.1; also elsewhere on the board
Fplay: R45.2, U14.11
Fpush: R34.2, U13.13
Frec: R33.2, U13.11
GND: C65.2, C66.2, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R41.1, R42.1, R43.1, R44.1, R45.1, U13.7 (VSS), U14.7 (VSS); also elsewhere on the board
unnamed: R35.2, U13.2
unnamed: R36.2, U13.4
unnamed: R37.2, U13.6
unnamed: R38.2, U13.8
unnamed: R39.2, U13.10
unnamed: R40.2, U13.12
unnamed: R47.2, U14.2
unnamed: R48.2, U14.4
unnamed: R49.2, U14.6
unnamed: R50.2, U14.8
unnamed: R51.2, U14.10
play: R37.1
push: R40.1
rec: R39.1

Notes on the sheet:
1M pull downs changed to 3.3M 1/3
add 40106 for touch input (freeze x10 and rec, play, push/mode = x13 which is 3x 40106) freeze is now pull to +V so held to GND - inverted. push is mode now

Parts:
J3: Conn_02x20_Counter_Clockwise; Pin_Header_Straight_2x20_Pitch2.54mm

Connections:
+12V: J3.5, J3.12; also elsewhere on the board
ADC0: J3.21; also elsewhere on the board
ADC1: J3.29; also elsewhere on the board
ADC2: J3.36; also elsewhere on the board
ADC3: J3.34; also elsewhere on the board
ADC4: J3.18; also elsewhere on the board
ADC5: J3.16; also elsewhere on the board
ADC6: J3.1; also elsewhere on the board
ADC7: J3.3; also elsewhere on the board
ADC12: J3.22; also elsewhere on the board
ADC13: J3.23; also elsewhere on the board
ADC14: J3.19; also elsewhere on the board
C1amped: J3.15; also elsewhere on the board
C2amped: J3.40; also elsewhere on the board
C3amped: J3.20; also elsewhere on the board
C4amped: J3.2; also elsewhere on the board
F1: J3.13; also elsewhere on the board
F2: J3.35; also elsewhere on the board
F3: J3.37; also elsewhere on the board
F4: J3.30; also elsewhere on the board
F5: J3.10; also elsewhere on the board
F6: J3.26; also elsewhere on the board
F7: J3.11; also elsewhere on the board
F8: J3.6; also elsewhere on the board
GND: J3.8, J3.9, J3.28, J3.33; also elsewhere on the board
PWM1amped: J3.38; also elsewhere on the board
PWM2amped: J3.24; also elsewhere on the board
PWM3amped: J3.14; also elsewhere on the board
PWM4amped: J3.17; also elsewhere on the board
PWMxamped: J3.32; also elsewhere on the board
TRIGG: J3.4; also elsewhere on the board
