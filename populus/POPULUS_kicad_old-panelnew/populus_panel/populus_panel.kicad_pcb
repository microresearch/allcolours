# Repository microresearch/allcolours (continued)

## KiCad design Offset_torework/offset_kicad.kicad_pcb

Parts:
C1, C2: 10u; CP_EIA-3216-18_Kemet-A
C3, C12, C13, C14: 100P; C_0805_2012Metric; LCSC C1790
C4, C5, C6, C7, C8, C9, C10, C11: 100N; C_0805_2012Metric; LCSC C49678
D1, D2: 1N5819; D_SOD-123; LCSC C82544
D3, D4, D5, D6: 1N4148-Diode; D_SOD-123; LCSC C81598
M1, M2, M3, M4, M6, M7, M8, M9, M10, M11, M12, M13, M14, M16, M19, M20: AUDIO-JACKERTHENVAR-PJ398; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHolesKEEPOUT
P1: CONN_02X05; PinHeader_2x05_P2.54mm_Vertical
Q1, Q2, Q3, Q4: Q_PNP_BEC; SOT-23; LCSC C53444
R1, R39, R40, R41: 6K8; R_0805_2012Metric; LCSC C114550
R2, R10, R11, R12, R13, R17, R19, R21, R23, R24, R25, R26, R54, R55, R56, R61: 10K; R_0805_2012Metric; LCSC C17414
R3, R4, R27, R28, R29, R30, R31, R32: 330K; R_0805_2012Metric; LCSC C17629
R5, R33, R34, R35: 39K; R_0805_2012Metric; LCSC C25632
R6, R8, R9, R15, R36, R37, R38, R43, R45, R47, R48, R49, R50, R64, R67, R68: 1K; R_0805_2012Metric; LCSC C17513
R7, R42, R44, R46: 100K; R_0805_2012Metric; LCSC C149504
R16, R18, R20, R22: 100R; R_0805_2012Metric; LCSC C106949
R51, R53, R57, R58, R59, R60, R62: 20K; R_0805_2012Metric; LCSC C4328
R52: 20k; R_0805_2012Metric; LCSC C4328
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8: R_POT; Potentiometer_Alps-RK09
U4, U8: TL074; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C12594
U5, U6: LM13700; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C174050

Connections:
-12V: C2.2, C5.1, C7.1, C9.1, C11.1, D1.2 (A), R17.1, R19.1, R21.1, R23.1, RV2.3, RV6.3, RV7.3, RV8.3, U4.11 (V-), U5.6 (V-), U6.6 (V-), U8.11 (V-)
GND: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, M1.1 (RING), M2.1 (RING), M3.1 (RING), M4.1 (RING), M6.1 (RING), M7.1 (RING), M8.1 (RING), M9.1 (RING), M10.1 (RING), M11.1 (RING), M12.1 (RING), M13.1 (RING), M14.1 (RING), M16.1 (RING), M19.1 (RING), M20.1 (RING), P1.3, P1.4, P1.5, P1.6, P1.7, P1.8, R6.1, R8.2, R9.1, R16.2, R18.2, R20.2, R22.2, R36.1, R37.1, R38.1, R43.2, R45.1, R47.2, R48.2, R49.1, R50.1, RV2.1, RV6.1, RV7.1, RV8.1, U4.3 (+), U4.5 (+), U4.10 (+), U4.12 (+), U5.7, U5.10, U6.7, U6.10, U8.3 (+), U8.5 (+), U8.10 (+), U8.12 (+)
unnamed: C3.1, D3.2 (A), Q1.1 (B), U4.1
unnamed: C3.2, D3.1 (K), R3.1, R4.1, R5.2, U4.2 (-)
unnamed: C12.1, D4.2 (A), Q2.1 (B), U4.7
unnamed: C12.2, D4.1 (K), R27.1, R28.1, R33.2, U4.6 (-)
unnamed: C13.1, D5.2 (A), Q3.1 (B), U4.8
unnamed: C13.2, D5.1 (K), R29.1, R30.1, R34.2, U4.9 (-)
unnamed: C14.1, D6.2 (A), Q4.1 (B), U4.14
unnamed: C14.2, D6.1 (K), R31.1, R32.1, R35.2, U4.13 (-)
unnamed: D1.1 (K), P1.9, P1.10
unnamed: D2.2 (A), P1.1, P1.2
unnamed: M1.3 (TIP), R3.2
unnamed: M2.3 (TIP), R7.2
unnamed: M3.3 (TIP), R10.2
unnamed: M4.3 (TIP), R15.1
unnamed: M6.3 (TIP), R27.2
unnamed: M7.3 (TIP), R29.2
unnamed: M8.3 (TIP), R31.2
unnamed: M9.3 (TIP), R42.2
unnamed: M10.3 (TIP), R44.2
unnamed: M11.3 (TIP), R46.2
unnamed: M12.3 (TIP), R51.2
unnamed: M13.3 (TIP), R54.2
unnamed: M14.3 (TIP), R57.2
unnamed: M16.3 (TIP), R64.1
unnamed: M19.3 (TIP), R67.1
unnamed: M20.3 (TIP), R68.1
unnamed: Q1.2 (E), R5.1, R6.2
unnamed: Q1.3 (C), R1.2
unnamed: Q2.2 (E), R33.1, R36.2
unnamed: Q2.3 (C), R39.2
unnamed: Q3.2 (E), R34.1, R37.2
unnamed: Q3.3 (C), R40.2
unnamed: Q4.2 (E), R35.1, R38.2
unnamed: Q4.3 (C), R41.2
unnamed: R1.1, U6.1
unnamed: R2.1, RV1.3
unnamed: R4.2, RV1.2
unnamed: R7.1, R9.2, U6.4 (-)
unnamed: R8.1, U6.3 (+)
unnamed: R10.1, R11.1, R12.1, R13.2, U8.2 (-)
unnamed: R11.2, U6.5
unnamed: R12.2, RV2.2
unnamed: R13.1, R15.2, U8.1
unnamed: R16.1, R17.2, RV1.1
unnamed: R18.1, R19.2, RV3.1
unnamed: R20.1, R21.2, RV4.1
unnamed: R22.1, R23.2, RV5.1
unnamed: R24.1, RV3.3
unnamed: R25.1, RV4.3
unnamed: R26.1, RV5.3
unnamed: R28.2, RV3.2
unnamed: R30.2, RV4.2
unnamed: R32.2, RV5.2
unnamed: R39.1, U5.16
unnamed: R40.1, U6.16
unnamed: R41.1, U5.1
unnamed: R42.1, R45.2, U5.13 (-)
unnamed: R43.1, U5.14 (+)
unnamed: R44.1, R49.2, U6.13 (-)
unnamed: R46.1, R50.2, U5.4 (-)
unnamed: R47.1, U6.14 (+)
unnamed: R48.1, U5.3 (+)
unnamed: R51.1, R52.1, R53.1, R60.2, U8.6 (-)
unnamed: R52.2, U5.12
unnamed: R53.2, RV6.2
unnamed: R54.1, R55.1, R56.1, R61.2, U8.9 (-)
unnamed: R55.2, U6.12
unnamed: R56.2, RV7.2
unnamed: R57.1, R58.1, R59.1, R62.2, U8.13 (-)
unnamed: R58.2, U5.5
unnamed: R59.2, RV8.2
unnamed: R60.1, R64.2, U8.7
unnamed: R61.1, R67.2, U8.8
unnamed: R62.1, R68.2, U8.14

Notes on the sheet:
Upper left
Lower left
1st
4x VCA, offset
2x OUT - middle lower
Left
For VCA doubling use 20k for all resistors...
Right
euro_conn
Right

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
Board: 2 copper layers, 70.0 x 105.0 mm, 117 parts (93 on the bottom side), 77 nets.

## Code that names these connections

File touch/software/main.c (part):

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       //GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_NOPULL;
       GPIO_Init(GPIOA, &GPIO_InitStructure);

       // PWM TIM1 on PA8
       GPIO_PinAFConfig(GPIOA, GPIO_PinSource8, GPIO_AF_TIM1);
       GPIO_InitStructure.GPIO_Pin = GPIO_Pin_8;
       GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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       GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
       GPIO_Init(GPIOA, &GPIO_InitStructure);

       // PWMx TIM2 CH2 on PB5
       
       GPIO_PinAFConfig(GPIOB, GPIO_PinSource5, GPIO_AF_TIM2);
       GPIO_InitStructure.GPIO_Pin = GPIO_Pin_5;
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       GPIO_Init(GPIOB, &GPIO_InitStructure);

       
       // PWM TIM4 on  //TIM4_CH2 - PB7 pin 59 
       GPIO_PinAFConfig(GPIOB, GPIO_PinSource7, GPIO_AF_TIM4);
       GPIO_InitStructure.GPIO_Pin = GPIO_Pin_7;
       GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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       GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
       GPIO_Init(GPIOB, &GPIO_InitStructure);

       // PWM - TIM8_CH2 - PC7 pin 38 
       GPIO_PinAFConfig(GPIOC, GPIO_PinSource7, GPIO_AF_TIM8);
       GPIO_InitStructure.GPIO_Pin = GPIO_Pin_7;
       GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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       GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
       GPIO_Init(GPIOC, &GPIO_InitStructure);

       // - TIM12_CH1 PB14 pin 35 // moved FR6 was pin PB14
       GPIO_PinAFConfig(GPIOB, GPIO_PinSource14, GPIO_AF_TIM12);
       GPIO_InitStructure.GPIO_Pin = GPIO_Pin_14;
       GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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	ADC_Init(ADC1, &ADC_InitStructure);
	ADC_Cmd(ADC1, ENABLE);
	/*
	  PA0->PA3 4
	  PA5->PA7 3
	  PC0->PC2 3
	  PB0(ADC4), PB1(ADC8) ???
	*/

    
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    //    GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_NOPULL; // changes nothing
    GPIO_Init(GPIOA, &GPIO_InitStructure);
    
    // adc8 is adc1_10 =pc0
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_0 | GPIO_Pin_1 | GPIO_Pin_2 | GPIO_Pin_3 | GPIO_Pin_4 | GPIO_Pin_5;// | GPIO_Pin_1; PC10  and 11 12 + added some
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
    GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_NOPULL;
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    GPIO_Init(GPIOB, &GPIO_InitStructure);

    
    //- DONE rec on PB2, play on PB4 - swopped with FR3, push on PB6 
    //- FR1-7 on PB8-15, FR8 on PC4 (inverted ins from 40106 so low is on!) // FR8 is now PB4
    /*
  RCC_AHB1PeriphClockCmd(RCC_AHB1Periph_GPIOB, ENABLE);
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_2;
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  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOB, &GPIO_InitStructure);

  // 19/8/2024 now use as PWM so swopped -> PB3 DONE // FR6
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_3;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN;
  GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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  // TEST - PC8 input from 40106 for freezing/rec/play etc. power it with 3.3v

  // led first
  //  GPIOA->MODER = (1 << 10); // set pin PA5 to be general purpose output

  // internal DAC PA4 with multiplex with EN_LOW1 on PC11 and sel1/2/3 on PC13/14/15

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_11;
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  TIM_ITConfig(TIM2, TIM_IT_Update, ENABLE);
  
  
  // set enable=say 13 and 14 pin (active LOW) and pins for 4051: PB8,9,10
  //    GPIOC->BSRRH = 0b1110100000000000;  // clear PC11 - clear pc11 and top bits -> low

  //    uint8_t firstByte, secondByte, configBits;
      uint32_t daccount=0;    
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      /* TRIAL PWM on
	 35: TIM12_CH1
	 38: TIM8_CH2
	 41: TIM1_CH1 PA8
	 59: TIM4_CH2
	 //	 prev PWM code from: segments
      */
  // TIM1 on PA8      
  TIM_DeInit(TIM1);
  RCC_APB2PeriphClockCmd(RCC_APB2Periph_TIM1, ENABLE);
  
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  TIM_Cmd(TIM1, ENABLE);
  TIM_CtrlPWMOutputs(TIM1, ENABLE); // we needed this for timer1 to be added

 //TIM4_CH2 - PB7 pin 59
  TIM_DeInit(TIM4);
  RCC_APB1PeriphClockCmd(RCC_APB1Periph_TIM4, ENABLE);
  
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  TIM_Cmd(TIM4, ENABLE);
  TIM_CtrlPWMOutputs(TIM4, ENABLE); // we needed this for timer1 to be added

  //- TIM8_CH2 - PC7 pin 38 
  TIM_DeInit(TIM8);
  RCC_APB2PeriphClockCmd(RCC_APB2Periph_TIM8, ENABLE);
  
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  TIM_Cmd(TIM8, ENABLE);
  TIM_CtrlPWMOutputs(TIM8, ENABLE); // we needed this for timer1 to be added

  // TIM12_CH1 PB14 pin 35 
  TIM_DeInit(TIM12);
  RCC_APB1PeriphClockCmd(RCC_APB1Periph_TIM12, ENABLE);
  
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      // all now placed in interrupt so is well timed
      // TODO - test freeze and all buttons
      //  daccount=1;
      //    GPIOC->BSRRH = 0b1110100000000000;  // clear PC11 - clear pc11 and top bits -> low
      //      delay();
      //      GPIOC->BSRRL = 0b1110000000000000;       // write PC13/14/15  -> DAC8 which is v4 top right, 7 is v3 top left, 6 is v2 lower left, 5 is v1 lower right
  //  GPIOC->BSRRL=(daccount)<<13; // for now just top bits
  //  GPIOC->BSRRL = 0b001000000000000;       // write PC13/14/15  -> DAC8 which is v4 top right, 7 is v3 top left, 6 is v2 lower left, 5 is v1 lower right
      //      GPIOC->BSRRL = 0b1000000000000000;      // now we want to test the VCAs-> lower bits so 1 is lower right
  //k=4095; // peak 6.6v      
  //DAC_SetChannel1Data(DAC_Align_12b_R, dacval[daccount]); // 1000/4096 * 3V3 == 0V8
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      //  if (daccount==8) daccount=0;  
      //    delay();
    /*    
    GPIOA->BSRRH = 1<<9;//0b0000000010000000;  // PA8
    delay();
    GPIOA->BSRRL = 1<<9;//0b0000000010000000;     
    delay();
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
File SR_segments/software/main.c (part):

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	mode_init();
	
  
  // inpulse interrupts to attach are: CSR: PC3-moved to PB7, NSR: PC4, RSR: PC5, LSR: PB6

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_7; // now is PB7
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN;
  GPIO_Init(GPIOB, &GPIO_InitStructure);

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  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN;
  GPIO_Init(GPIOB, &GPIO_InitStructure);

  // PC7/8 pulsein (LSR/RSR), PC9-MCB, to PC14-LSB of 6 bits
  
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_7;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN;
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  RCC_AHB1PeriphClockCmd(RCC_AHB1Periph_GPIOC, ENABLE);

  
  //  TIM1-CH1 norming to top clock is on PA8
  GPIO_PinAFConfig(GPIOA, GPIO_PinSource8, GPIO_AF_TIM1);
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_8;
  GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
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  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOA, &GPIO_InitStructure);

    // out pulses are on: PB2,3,4,10,12,13,14,15
  // PC15, PA11, PA12

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_2;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_OUT;
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  GPIO_Init(GPIOC, &GPIO_InitStructure);

  
  // TIM1 on PA8 to set up // working!
  
  TIM_DeInit(TIM1);
  RCC_APB2PeriphClockCmd(RCC_APB2Periph_TIM1, ENABLE);
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  TIM_ITConfig(TIM4, TIM_IT_Update, ENABLE);
  
  
  // inpulse interrupts to attach are: CSR: PC3->now PB7, NSR: PC4, RSR: PC5, LSR: PB6

  RCC_APB2PeriphClockCmd(RCC_APB2Periph_SYSCFG, ENABLE);

  SYSCFG_EXTILineConfig(EXTI_PortSourceGPIOC, EXTI_PinSource4);
  EXTI_InitStructure.EXTI_Line = EXTI_Line4; // PC4
  EXTI_InitStructure.EXTI_Mode = EXTI_Mode_Interrupt;
  EXTI_InitStructure.EXTI_Trigger = EXTI_Trigger_Falling; // changed to falling
  EXTI_InitStructure.EXTI_LineCmd = ENABLE;
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  NVIC_Init(&NVIC_InitStructure);

  SYSCFG_EXTILineConfig(EXTI_PortSourceGPIOC, EXTI_PinSource5);
  EXTI_InitStructure.EXTI_Line = EXTI_Line5; // PC5
  EXTI_InitStructure.EXTI_Mode = EXTI_Mode_Interrupt;
  EXTI_InitStructure.EXTI_Trigger = EXTI_Trigger_Falling; // changed to falling
  EXTI_InitStructure.EXTI_LineCmd = ENABLE;
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  NVIC_Init(&NVIC_InitStructure);

  SYSCFG_EXTILineConfig(EXTI_PortSourceGPIOB, EXTI_PinSource6);
  EXTI_InitStructure.EXTI_Line = EXTI_Line6; // PB6
  EXTI_InitStructure.EXTI_Mode = EXTI_Mode_Interrupt;
  EXTI_InitStructure.EXTI_Trigger = EXTI_Trigger_Falling; // changed to falling
  EXTI_InitStructure.EXTI_LineCmd = ENABLE;
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  NVIC_Init(&NVIC_InitStructure);

  
  SYSCFG_EXTILineConfig(EXTI_PortSourceGPIOB, EXTI_PinSource7); // adding PB7
  EXTI_InitStructure.EXTI_Line = EXTI_Line7; // PB7
  EXTI_InitStructure.EXTI_Mode = EXTI_Mode_Interrupt;
  EXTI_InitStructure.EXTI_Trigger = EXTI_Trigger_Falling; // changed to falling
  EXTI_InitStructure.EXTI_LineCmd = ENABLE;
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  
    while(1) {

  // test in gives out on PB4 - always inverted...

      // test pulse ins on... PC7 PC8?

      //      if ((GPIOC->IDR & (1<<8)))  GPIOB->BSRRH = (1)<<4;  // clear bits PB4
      //      else   GPIOB->BSRRL=(1)<<4; //  write bits   

      
      // test pulse outs one by one:
      // L1-PB2, L2-PC15, R1-PB3, R2-PA11, C1-PB4, C2-PA12

      // normed/fake pulses are: LSR-pulse8=PB10, RSR-pulse7=PB15, LSRCLK-pulse9=PB12, RSRCLK-pulse10=PB13, CSRCLCK-pulse11=PB14

       // toggle bits test
      // out pulses are on: PB2,3,4,10,12,13,14,15 // checked and all working!
      /*
      GPIOC->BSRRH = (1<<15) ;  // clear bits            
      GPIOB->BSRRH = (1)<<2 | (1<<3) | (1<<4) | (1<<10) | (1<<12)  | (1<<13)  | (1<<14) | (1<<15) ;  // clear bits
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
File software/STM32F103/src/main.c (part):

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
- I/O map from new schematic:

  - LF: PWM out-tim3c1->PB4X, clock pin interrupt in->PB5-EXTI5X, pulse in->PB6, 2X pulse out=inverted=PB13,14
  - HF: PWM out-tim1c1->PA8X, clock pin interrupt in->PB7=EXTI7X, pulse in->PB10//can be interrupt tooX, 2 pulse out=inverted=PC13,14

  + 4xcv adc - modeh CV, model cv, speedl cv, speedh cv = ADC0(modeh),1(model),2(speedh),3(speedl)=PA0,1,2,3 X

  + LF timer loop/interrupt (which updates all CVs) =timer4
  + HF timer loop =timer2
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  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_0;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOA, &GPIO_InitStructure); // in PA1
 
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_1;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOA, &GPIO_InitStructure); // in PA2

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_2;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOA, &GPIO_InitStructure); // in PA3

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_3;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AIN;
  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOA, &GPIO_InitStructure); // in PA4

  ADC_DeInit(ADC1);
  ADC_InitStructure.ADC_ContinuousConvMode = ENABLE; // in worm was disable but works now
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  
  // two PWM - fast (speed range- 2MHz->x) and slow (speed range???) on 2 pins
  // example for A0
  // converted to timer1 -> T1C1= PA8    
  // this is HF PWM on PA8 - timer 1 channel 1
  
  TIM_DeInit(TIM1);

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  TIM_Cmd(TIM1, ENABLE);
  TIM_CtrlPWMOutputs(TIM1, ENABLE); // we needed this for timer1 to be added
  
  // this is LF PWM on PB4 - timer 3 channel 1 -> TESTED!

  TIM_DeInit(TIM3);
  RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOB | RCC_APB2Periph_AFIO, ENABLE);
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  TIM_OC_InitStructure.TIM_OutputState = TIM_OutputState_Enable;
  TIM_OC_InitStructure.TIM_OutputNState = TIM_OutputNState_Disable;
  TIM_OC_InitStructure.TIM_Pulse = 16; // pulse size
  TIM_OC1Init(TIM3, &TIM_OC_InitStructure); // T3C1 is pin PB4
  TIM_ARRPreloadConfig(TIM3, ENABLE); // we needed this!
  TIM_OC1PreloadConfig(TIM3, TIM_OCPreload_Enable); 
  TIM_Cmd(TIM3, ENABLE);
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  // 2 pin interrupts (falling edge as inverted)
  // test on pin 0 - port B - check where EXTI lines go in manual

  //LF:PB5-EXTI5X  HF:PB7=EXTI7X
      
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_7;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN_FLOATING;
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  TIM_Cmd(TIM4, ENABLE);
 
  // Configure pins as output push-pull -
  // FOR pulse outs: LF: PB13,14 HF: PC13,14

  RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOC, ENABLE);
  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_13;
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  GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
  GPIO_Init(GPIOB, &GPIO_InitStructure);
  
  // for additional pulse ins: PB6 and PB10

  GPIO_InitStructure.GPIO_Pin = GPIO_Pin_6;
  GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN_FLOATING;
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
File software/microbdeurojuly29.c (part):

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
DONE:

- and others question of random and also speed *now last knob CV = PC0
and PC5 should replace rand and first is BOTH plague and CPU* DONE
- out is on PD6 now // was PD6=0C0A DONE
- adcread(3) as open/random or ???? - should now be (adcread(0)+adcread(5)) - DONE - STILL TODO????
- remove filter/filtermod and other hardware DONE
- speed setting = pinX DONE - maybe 2 different speeds lower and upper bitsDONE
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- additional instructions and plague simulations

//////
1-RV1=CV2=// PC2+PC4 (latter in all is CV)
2-RV3=CV3=// PC0+PC5
3-MID top/bottom// RV2=CV1=// PC1+PC3 =speed
- THE PLAGUE INTERPRETER

... to bring back to all of us a natural, occult equivalent of the
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        TCCR0A=(1<<COM0A1) | (1<<WGM01) | (1<<WGM00); 
        TCCR0B=(1<<CS00) | (1<<CS01);  // divide by 64 for 1KHz

      DIDR0=0x3f; // disable digital inputs on PC0 to PC5
    //    sbi(TIMSK0, TOIE0);

  //  cbi(PORTD,PD0);
  //  sbi(PORTD,PD1); 
  //  cbi(PORTD,PD2); // feedback

  instructionp=0; insdir=1; dir=1; btdir=0; dcdir=0;

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
File software/all_colours.c (part):

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
/////

1 pulse ins, 1 clock pulse in on each side LF, HF (these 2 are two interrupts PD2, PD3, INT0, INT1) -> all inverted

- modeh CV, model cv, speedl cv, speedh cv 

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  return out; //
}

ISR(INT0_vect) // doesn't run faster than 444 KHz - pin2 PD2 - pin interrupt
{
  //    PORTB=1; //pin 8 PB0
  //    PORTB=0;
  //  PinVal(PORTB, 0, 1);
  //  PinVal(PORTB, 0, 0);  
  PORTB=lfsr8(); //    59KHz is fastest for this as it stands = around 1K filter even with changes to filter design
}

ISR(INT1_vect) // doesn't run faster than 444 KHz - pin3 PD3
{
  //  PORTB=1; //pin 8 PB0
  //  PORTB=0;
  //  PinVal(PORTD, 0, 1); // pin PD0 = 0
  //  PinVal(PORTD, 0, 0);  
}

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SIGNAL(TIMER0_COMPA_vect) // again around 444 KHz speed 
{

  // test toggle pin 8 PB0
  //    PORTB=1; // in main loop this gives us 4 MHz
  //    PORTB=0;
  //  OCR0A = 0x0F; // 0xOF should be 1 MHz - but fastest we go is 444 Khz = 4K filter  
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  */

  // for c/no arduino
  DDRD=0x80; // PD7 pin 7
  DDRB=0x0b;

  cli();//stop interrupts
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  
    // 1024= 7 Khz= 7000/100=70Hz 1khz-10Hz in the filter

  // set up interrupt INT0 on pin PD2 which is arduino pin 2

    // but as inverted we want falling edge and also INT1 - test this
     
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
## Commit log (part)

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2022-12-09 imac
2023-01-27 lletc
2023-02-24 Closer to caput draconis as the crescent moon moves into the northern ecliptic hemisphere at 18.56 GMT this evening.
    Successive pleasurable and tortuous dislocations
2023-02-24 dac fix
2023-03-05 xxcccxx
2023-03-09 fini
2023-03-18 1111
2023-03-19 freezeit!
2023-03-19 not quite
2023-03-19 fix?
2023-03-19 fix2
2023-03-20 equinox!
2023-03-21 final cpaut
2023-03-23 final caput
2023-04-03 pcb new
2023-04-05 toad/touch
2023-04-24 final toad
2023-04-25 xxcomp
2023-05-23 touch bom to check
2024-02-01 new VIA restart
